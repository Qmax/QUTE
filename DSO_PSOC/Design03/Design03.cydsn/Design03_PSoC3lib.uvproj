# Keil uVision project Design03_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246AXA-138 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Design03_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h BCH1_DIV0_RLY.c BCH1_DIV0_RLY.h BCH1_DIV0_RLY_aliases.h BCH1_DIV1_RLY.c BCH1_DIV1_RLY.h BCH1_DIV1_RLY_aliases.h BCH1_CALIB_RLY.c BCH1_CALIB_RLY.h BCH1_CALIB_RLY_aliases.h BCH2_DIV0_RLY.c BCH2_DIV0_RLY.h BCH2_DIV0_RLY_aliases.h BCH2_DIV1_RLY.c BCH2_DIV1_RLY.h BCH2_DIV1_RLY_aliases.h BCH2_CALIB_RLY.c BCH2_CALIB_RLY.h BCH2_CALIB_RLY_aliases.h BTRG_EXT5_RLY.c BTRG_EXT5_RLY.h BTRG_EXT5_RLY_aliases.h SAMPLEMODE_S0.c SAMPLEMODE_S0.h SAMPLEMODE_S0_aliases.h SAMPLEMODE_S1.c SAMPLEMODE_S1.h SAMPLEMODE_S1_aliases.h CH1_CUPSEL0_RLY.c CH1_CUPSEL0_RLY.h CH1_CUPSEL0_RLY_aliases.h CH1_CUPSEL1_RLY.c CH1_CUPSEL1_RLY.h CH1_CUPSEL1_RLY_aliases.h CH2_CUPSEL0_RLY.c CH2_CUPSEL0_RLY.h CH2_CUPSEL0_RLY_aliases.h CH2_CUPSEL1_RLY.c CH2_CUPSEL1_RLY.h CH2_CUPSEL1_RLY_aliases.h ATTN_SEL0.c ATTN_SEL0.h ATTN_SEL0_aliases.h ATTN_SEL1.c ATTN_SEL1.h ATTN_SEL1_aliases.h ATTN_SEL2.c ATTN_SEL2.h ATTN_SEL2_aliases.h ATTN_SEL3.c ATTN_SEL3.h ATTN_SEL3_aliases.h FILTER_SEL.c FILTER_SEL.h FILTER_SEL_aliases.h TRIG_HSYS_SEL0.c TRIG_HSYS_SEL0.h TRIG_HSYS_SEL0_aliases.h TRIG_HSYS_SEL1.c TRIG_HSYS_SEL1.h TRIG_HSYS_SEL1_aliases.h PSOC_SPI_CS.c PSOC_SPI_CS.h PSOC_SPI_CS_aliases.h PSOC_SPI_CLK.c PSOC_SPI_CLK.h PSOC_SPI_CLK_aliases.h PSOC_SPI_DI.c PSOC_SPI_DI.h PSOC_SPI_DI_aliases.h PSOC_SPI_DO.c PSOC_SPI_DO.h PSOC_SPI_DO_aliases.h SP6_SPI_CSSEL.c SP6_SPI_CSSEL.h SP6_SPI_CSSEL_aliases.h FLASH_SPI_CS.c FLASH_SPI_CS.h FLASH_SPI_CS_aliases.h FLASH_SPI_CK.c FLASH_SPI_CK.h FLASH_SPI_CK_aliases.h FLASH_SPI_DI.c FLASH_SPI_DI.h FLASH_SPI_DI_aliases.h FLASH_SPI_DO.c FLASH_SPI_DO.h FLASH_SPI_DO_aliases.h SPIS.c SPIS.h SPIS_PM.c SPIS_INT.c SPIS_BOOT.c SPIS_PVT.h SPIS_IntClock.c SPIS_IntClock.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3246AXA-138 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Design03_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
