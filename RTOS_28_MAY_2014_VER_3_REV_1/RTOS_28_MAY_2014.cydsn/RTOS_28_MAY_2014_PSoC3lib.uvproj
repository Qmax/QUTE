# Keil uVision project RTOS_28_MAY_2014_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246AXI-138 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: RTOS_28_MAY_2014_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU RTX51TINY
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h RTX51_config.a51 RTX51.c RTX51.h Clock.c Clock.h UART.c UART.h UART_PM.c UART_INT.c UART_BOOT.c isr.c isr.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h k_isr.c k_isr.h KEY.c KEY.h KEY_aliases.h K1_SENSE.c K1_SENSE.h K1_SENSE_aliases.h K2_SENSE.c K2_SENSE.h K2_SENSE_aliases.h PSoC_INT0.c PSoC_INT0.h PSoC_INT0_aliases.h PSoC_INT1.c PSoC_INT1.h PSoC_INT1_aliases.h MOSI.c MOSI.h MOSI_aliases.h MISO.c MISO.h MISO_aliases.h SPIM.c SPIM.h SPIM_PM.c SPIM_INT.c SPIM_PVT.h SCK.c SCK.h SCK_aliases.h CSN.c CSN.h CSN_aliases.h SPIM_IntClock.c SPIM_IntClock.h Clk_PWM.c Clk_PWM.h PWM_Out.c PWM_Out.h PWM_Out_aliases.h PWM.c PWM.h PWM_PM.c U_CLOCK.c U_CLOCK.h cydisabledsheets.h EMISO.c EMISO.h EMISO_aliases.h ECS.c ECS.h ECS_aliases.h ECLK.c ECLK.h ECLK_aliases.h EMOSI.c EMOSI.h EMOSI_aliases.h SPIS.c SPIS.h SPIS_PM.c SPIS_INT.c SPIS_BOOT.c SPIS_PVT.h DEC_INT.c DEC_INT.h DEC_INT_aliases.h isr_QD.c isr_QD.h Clock_QD.c Clock_QD.h EN_SW1.c EN_SW1.h EN_SW1_aliases.h EN_CHB.c EN_CHB.h EN_CHB_aliases.h EN_CHA.c EN_CHA.h EN_CHA_aliases.h QuadDecoder.c QuadDecoder.h QuadDecoder_PM.c Key2_2.c Key2_2.h Key2_2_aliases.h Key2_1.c Key2_1.h Key2_1_aliases.h Key2_0.c Key2_0.h Key2_0_aliases.h Key1_1.c Key1_1.h Key1_1_aliases.h Key1_0.c Key1_0.h Key1_0_aliases.h Key1_2.c Key1_2.h Key1_2_aliases.h PC_VI_2SEL0.c PC_VI_2SEL0.h PC_VI_2SEL0_aliases.h BICM_SEL.c BICM_SEL.h BICM_SEL_aliases.h BFG1_SEL.c BFG1_SEL.h BFG1_SEL_aliases.h MUXASEL.c MUXASEL.h MUXASEL_aliases.h SRC_0.c SRC_0.h SRC_0_aliases.h SRC_1.c SRC_1.h SRC_1_aliases.h SRC_2.c SRC_2.h SRC_2_aliases.h SRC_3.c SRC_3.h SRC_3_aliases.h SRC_4.c SRC_4.h SRC_4_aliases.h PC_VI_2SEL1.c PC_VI_2SEL1.h PC_VI_2SEL1_aliases.h SPIS_IntClock.c SPIS_IntClock.h GPIO0_5V.c GPIO0_5V.h GPIO0_5V_aliases.h BSRC_IMP_SEL.c BSRC_IMP_SEL.h BSRC_IMP_SEL_aliases.h GPIO5.c GPIO5.h GPIO5_aliases.h QuadDecoder_Cnt8.c QuadDecoder_Cnt8.h QuadDecoder_Cnt8_PM.c MUXSEL_B0.c MUXSEL_B0.h MUXSEL_B0_aliases.h MUXSEL_B1.c MUXSEL_B1.h MUXSEL_B1_aliases.h
target Release (MCS-51)
  device: CY8C3246AXI-138 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: RTOS_28_MAY_2014_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
