# Keil uVision project Design01_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246AXI-138 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Design01_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h ISO_SCS.c ISO_SCS.h ISO_SCS_aliases.h ISO_SCLK.c ISO_SCLK.h ISO_SCLK_aliases.h ISO_SDI.c ISO_SDI.h ISO_SDI_aliases.h ISO_SDO.c ISO_SDO.h ISO_SDO_aliases.h ISO_DI0.c ISO_DI0.h ISO_DI0_aliases.h CS.c CS.h CS_aliases.h CK.c CK.h CK_aliases.h DIn.c DIn.h DIn_aliases.h DOut.c DOut.h DOut_aliases.h RL6_CTR.c RL6_CTR.h RL6_CTR_aliases.h RL1_CTR.c RL1_CTR.h RL1_CTR_aliases.h RL4_CTR.c RL4_CTR.h RL4_CTR_aliases.h RL3_CTR.c RL3_CTR.h RL3_CTR_aliases.h RL2_CTR.c RL2_CTR.h RL2_CTR_aliases.h RL5_CTR.c RL5_CTR.h RL5_CTR_aliases.h RL7_CTR.c RL7_CTR.h RL7_CTR_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h cydisabledsheets.h ISO_DI2.c ISO_DI2.h ISO_DI2_aliases.h ISO_DI1.c ISO_DI1.h ISO_DI1_aliases.h I2C_1.c I2C_1.h I2C_1_BOOT.c I2C_1_INT.c I2C_1_PM.c I2C_1_SLAVE.c I2C_1_MASTER.c I2C_1_PVT.h I2C1_SCL.c I2C1_SCL.h I2C1_SCL_aliases.h I2C1_SDA.c I2C1_SDA.h I2C1_SDA_aliases.h
target Release (MCS-51)
  device: CY8C3246AXI-138 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Design01_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
